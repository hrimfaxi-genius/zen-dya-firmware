## boards/shields/zen/Kconfig.shield
```kconfig
config SHIELD_ZEN_LEFT
    def_bool $(shields_list_contains,zen_left)

config SHIELD_ZEN_RIGHT
    def_bool $(shields_list_contains,zen_right)
```
